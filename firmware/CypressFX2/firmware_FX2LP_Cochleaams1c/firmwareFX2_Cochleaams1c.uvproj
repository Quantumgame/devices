# Keil uVision project firmwareFX2_Cochleaams1c.uvproj, settings and files
target firmware (MCS-51)
  device: EZ-USB FX2LP (CY7C68XXX-X) Cypress Semiconductor
  cpu: IRAM(0-0xFF) XRAM(0xE000-0xE3FF) CLOCK(48000000) MODDP2
  output: firmwareFX2_Cochleaams1c +hex
  AfterMake: makeHexBixCopyToJava.cmd
  c flags: Optimize=8
  group firmware source code
    ./: fw.c dscr.a51 biasgen.h main.c ports.h ports.c micro.c lenval.c lenval.h micro.h
    C:/Cypress/USB/CY3684_EZ-USB_FX2LP_DVK/1.0/Target/Inc/: syncdly.h lp.h lpregs.h lpregs.inc
    C:/Cypress/USB/CY3684_EZ-USB_FX2LP_DVK/1.0/Target/Lib/LP/: USBJmpTb.OBJ EZUSB.LIB
